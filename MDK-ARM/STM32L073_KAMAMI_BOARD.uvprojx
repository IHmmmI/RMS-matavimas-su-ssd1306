# Keil uVision project STM32L073_KAMAMI_BOARD.uvprojx, settings and files
target STM32L073_KAMAMI_BOARD (6240000::V6.24::ARMCLANG)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32L073_KAMAMI_BOARD +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../ST7789;../ST7789-main/Src;../ssd1306/Lab2_DemoFirmware/ssd1306-stm32HAL-master/lib;../Core/Src;../MDK-ARM;..\ssd1306;..\ssd1306\lib\ssd1306-stm32HAL-master\lib
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User/Core
    ./: ekranas.h ekranas.c
    ../Core/Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
    ../ssd1306/: fonts.c fonts.h ssd1306.c ssd1306.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
software components: CMSIS:CORE 6.2.0
